# Keil uVision project SmartFan.uvproj, settings and files
target SmartFan (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: fan_auto50_manual60 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\lcd1602;.\App\ired;.\App\fan
  group User
    ./User/: main.c
  group App
    ./App/lcd1602/: lcd1602.c
    ./App/ired/: ired.c
    ./App/fan/: fan.c
  group Public
    ./Public/: public.c
